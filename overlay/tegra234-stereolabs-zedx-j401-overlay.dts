// SPDX-License-Identifier: GPL-2.0-only
// Stereolabs ZED X / ZED X One GS GMSL overlay.

/dts-v1/;
/plugin/;

#include <dt-bindings/gpio/tegra234-gpio.h>
#include <dt-bindings/clock/tegra234-clock.h>
#include <dt-bindings/tegra234-p3767-0000-common.h>
/* BOARD_CONFIG_MARKER - Do not modify, auto-generated by Makefile */
#include "tegra234-stereolabs-zedx-j401-config.dtsi"

#define NUM_LANES	2
#define NUM_LANES_A	4
#define NUM_LANES_B	4

#define STR(x) #x
#define XSTR(x) STR(x)

#define ZED_ORIN_CLKS \
	clocks = <&bpmp TEGRA234_CLK_EXTPERIPH1>, \
		<&bpmp TEGRA234_CLK_EXTPERIPH1>; \
	clock-names = "extperiph1", "pllp_grtba"; \
	mclk = "extperiph1";

#define AR0234_MODES_LANES_CLK(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY, LANES, SERDES_PIX_CLK) \
	physical_w = "15.0"; \
	physical_h = "12.5"; \
	post_crop_frame_drop = "0"; \
	use_sensor_mode_id = "true"; \
	mode0 { \
		mclk_khz = "24000"; \
		num_lanes = XSTR(LANES); \
		tegra_sinterface = OPT_CSI_SERIAL; \
		lane_polarity = LANE_POLARITY; \
		vc_id = VC_ID; \
		discontinuous_clk = "no"; \
		dpcm_enable = "false"; \
		cil_settletime = "0"; \
		dynamic_pixel_bit_depth = "10"; \
		csi_pixel_bit_depth = "10"; \
		mode_type = "bayer"; \
		pixel_phase = "grbg"; \
		active_w = "1920"; \
		active_h = "1200"; \
		readout_orientation = "0"; \
		line_length = "12496"; \
		inherent_gain = "1"; \
		mclk_multiplier = "3.01"; \
		pix_clk_hz = "229500000"; \
		serdes_pix_clk_hz = SERDES_PIX_CLK; \
		gain_factor = "100"; \
		min_gain_val = "100"; \
		max_gain_val = "1600"; \
		step_gain_val = "1"; \
		default_gain = "100"; \
		min_hdr_ratio = "1"; \
		max_hdr_ratio = "1"; \
		framerate_factor = "1000000"; \
		min_framerate = "15000000"; \
		max_framerate = "60000000"; \
		step_framerate = "15000000"; \
		default_framerate = "30000000"; \
		exposure_factor = "1000000"; \
		min_exp_time = "28"; \
		max_exp_time = "66000"; \
		step_exp_time = "1"; \
		default_exp_time = "13000"; \
		embedded_metadata_height = "0"; \
	}; \
	mode1 { \
		mclk_khz = "24000"; \
		num_lanes = XSTR(LANES); \
		tegra_sinterface = OPT_CSI_SERIAL; \
		lane_polarity = LANE_POLARITY; \
		vc_id = VC_ID; \
		discontinuous_clk = "no"; \
		dpcm_enable = "false"; \
		cil_settletime = "0"; \
		dynamic_pixel_bit_depth = "10"; \
		csi_pixel_bit_depth = "10"; \
		mode_type = "bayer"; \
		pixel_phase = "grbg"; \
		active_w = "960"; \
		active_h = "600"; \
		readout_orientation = "0"; \
		line_length = "6248"; \
		inherent_gain = "1"; \
		mclk_multiplier = "3.01"; \
		pix_clk_hz = "229500000"; \
		serdes_pix_clk_hz = SERDES_PIX_CLK; \
		gain_factor = "100"; \
		min_gain_val = "100"; \
		max_gain_val = "1600"; \
		step_gain_val = "1"; \
		default_gain = "100"; \
		min_hdr_ratio = "1"; \
		max_hdr_ratio = "1"; \
		framerate_factor = "1000000"; \
		min_framerate = "15000000"; \
		max_framerate = "120000000"; \
		step_framerate = "15000000"; \
		default_framerate = "120000000"; \
		exposure_factor = "1000000"; \
		min_exp_time = "28"; \
		max_exp_time = "66000"; \
		step_exp_time = "1"; \
		default_exp_time = "8000"; \
		embedded_metadata_height = "0"; \
	}; \
	mode2 { \
		mclk_khz = "24000"; \
		num_lanes = XSTR(LANES); \
		tegra_sinterface = OPT_CSI_SERIAL; \
		lane_polarity = LANE_POLARITY; \
		vc_id = VC_ID; \
		discontinuous_clk = "no"; \
		dpcm_enable = "false"; \
		cil_settletime = "0"; \
		dynamic_pixel_bit_depth = "10"; \
		csi_pixel_bit_depth = "10"; \
		mode_type = "bayer"; \
		pixel_phase = "grbg"; \
		active_w = "1920"; \
		active_h = "1080"; \
		readout_orientation = "0"; \
		line_length = "12496"; \
		inherent_gain = "1"; \
		mclk_multiplier = "3.01"; \
		pix_clk_hz = "229500000"; \
		serdes_pix_clk_hz = SERDES_PIX_CLK; \
		gain_factor = "100"; \
		min_gain_val = "100"; \
		max_gain_val = "1600"; \
		step_gain_val = "1"; \
		default_gain = "100"; \
		min_hdr_ratio = "1"; \
		max_hdr_ratio = "1"; \
		framerate_factor = "1000000"; \
		min_framerate = "15000000"; \
		max_framerate = "60000000"; \
		step_framerate = "15000000"; \
		default_framerate = "30000000"; \
		exposure_factor = "1000000"; \
		min_exp_time = "28"; \
		max_exp_time = "66000"; \
		step_exp_time = "1"; \
		default_exp_time = "13000"; \
		embedded_metadata_height = "0"; \
	}; \
	mode3 { \
		mclk_khz = "24000"; \
		num_lanes = XSTR(LANES); \
		tegra_sinterface = OPT_CSI_SERIAL; \
		lane_polarity = LANE_POLARITY; \
		vc_id = VC_ID; \
		discontinuous_clk = "no"; \
		dpcm_enable = "false"; \
		cil_settletime = "0"; \
		dynamic_pixel_bit_depth = "10"; \
		csi_pixel_bit_depth = "10"; \
		mode_type = "bayer"; \
		pixel_phase = "grbg"; \
		active_w = "1920"; \
		active_h = "1200"; \
		readout_orientation = "0"; \
		line_length = "12496"; \
		inherent_gain = "1"; \
		mclk_multiplier = "3.01"; \
		pix_clk_hz = "229500000"; \
		serdes_pix_clk_hz = SERDES_PIX_CLK; \
		gain_factor = "100"; \
		min_gain_val = "100"; \
		max_gain_val = "1600"; \
		step_gain_val = "1"; \
		default_gain = "100"; \
		min_hdr_ratio = "1"; \
		max_hdr_ratio = "1"; \
		framerate_factor = "1000000"; \
		min_framerate = "15000000"; \
		max_framerate = "30000000"; \
		step_framerate = "15000000"; \
		default_framerate = "30000000"; \
		exposure_factor = "1000000"; \
		min_exp_time = "28"; \
		max_exp_time = "66000"; \
		step_exp_time = "1"; \
		default_exp_time = "13000"; \
		embedded_metadata_height = "0"; \
	};

#define AR0234_MODES(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY) \
	AR0234_MODES_LANES_CLK(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY, NUM_LANES, "299000000")

#define AR0234_MODES_A(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY) \
	AR0234_MODES_LANES_CLK(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY, NUM_LANES_A, "598000000")

#define AR0234_MODES_B(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY) \
	AR0234_MODES_LANES_CLK(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY, NUM_LANES_B, "598000000")

#define ZEDX_CAMERA_MODULE(ID, BADGE, POSITION, DEVNAME, PROC_DEV_TREE) \
	module##ID { \
		badge = BADGE; \
		position = POSITION; \
		orientation = "1"; \
		drivernode0 { \
			pcl_id = "v4l2_sensor"; \
			devname = DEVNAME; \
			proc-device-tree = PROC_DEV_TREE; \
		}; \
	};

#define ZEDX_VI_PORT(ID, REG_ID, VC_ID, VI_PORT_INDEX) \
	port@REG_ID { \
		reg = <REG_ID>; \
		zedx_vi_in##ID: endpoint { \
			vc-id = <VC_ID>; \
			port-index = <VI_PORT_INDEX>; \
			bus-width = <NUM_LANES>; \
			remote-endpoint = <&zedx_csi_out##ID>; \
		}; \
	};

#define ZEDX_CSI_CHANNEL(ID, REG_ID, CSI_PORT_INDEX) \
	channel@REG_ID { \
		reg = <REG_ID>; \
		ports { \
			#address-cells = <1>; \
			#size-cells = <0>; \
			port@0 { \
				reg = <0>; \
				zedx_csi_in##ID: endpoint@0 { \
					port-index = <CSI_PORT_INDEX>; \
					bus-width = <NUM_LANES>; \
					remote-endpoint = <&zedx_ar0234_out##ID>; \
				}; \
			}; \
			port@1 { \
				reg = <1>; \
				zedx_csi_out##ID: endpoint@1 { \
					remote-endpoint = <&zedx_vi_in##ID>; \
				}; \
			}; \
		}; \
	};

#define ZEDX_STEREO_SENSOR(SLOT, SIDE, UNIT_ADDR, REG_ADDR, DEVNODE, SYNC_NAME, SYNC_INDEX, ZEDX_ID, VC_ID, CSI_SERIAL, LANE_POLARITY, CSI_PORT_INDEX, OPT_CSI_PORT, OUT_ID) \
	zedx_##SIDE##SLOT: zedx_##SIDE##_##SLOT@UNIT_ADDR { \
		compatible = "stereolabs,zedx"; \
		reg = <REG_ADDR>; \
		ZED_ORIN_CLKS \
		devnode = DEVNODE; \
		sync_sensor = SYNC_NAME; \
		sync_sensor_index = <SYNC_INDEX>; \
		zedx-id = XSTR(ZEDX_ID); \
		channel = "a"; \
		has-eeprom; \
		eeprom-addr = <0x54>; \
		AR0234_MODES(XSTR(VC_ID), CSI_SERIAL, LANE_POLARITY) \
		ports { \
			#address-cells = <1>; \
			#size-cells = <0>; \
			port@0 { \
				reg = <0>; \
				zedx_ar0234_out##OUT_ID: endpoint { \
					vc-id = <VC_ID>; \
					port-index = <CSI_PORT_INDEX>; \
					opt-csi-port = OPT_CSI_PORT; \
					bus-width = <NUM_LANES>; \
					i2c-cc = <0>; \
					remote-endpoint = <&zedx_csi_in##OUT_ID>; \
				}; \
			}; \
		}; \
	};

#define ZEDX_ONE_GS_SENSOR(SLOT, UNIT_ADDR, REG_ADDR, DEVNODE, SYNC_NAME, ZEDX_ID, VC_ID, CSI_SERIAL, LANE_POLARITY, CSI_PORT_INDEX, OPT_CSI_PORT) \
	zedxone_gs##SLOT: zedxone_gs_##SLOT@UNIT_ADDR { \
		compatible = "stereolabs,zedx"; \
		reg = <REG_ADDR>; \
		ZED_ORIN_CLKS \
		devnode = DEVNODE; \
		sync_sensor = SYNC_NAME; \
		sync_sensor_index = <1>; \
		zedx-id = XSTR(ZEDX_ID); \
		channel = "a"; \
		has-eeprom; \
		eeprom-addr = <0x56>; \
		AR0234_MODES(XSTR(VC_ID), CSI_SERIAL, LANE_POLARITY) \
		ports { \
			#address-cells = <1>; \
			#size-cells = <0>; \
			port@0 { \
				reg = <0>; \
				zedxone_gs_out##SLOT: endpoint { \
					vc-id = <VC_ID>; \
					port-index = <CSI_PORT_INDEX>; \
					opt-csi-port = OPT_CSI_PORT; \
					bus-width = <NUM_LANES>; \
					i2c-cc = <0>; \
					remote-endpoint = <&zedxone_gs_csi_in##SLOT>; \
				}; \
			}; \
		}; \
	};

#define ZEDX_SERIALIZER(SLOT, UNIT_ADDR, REG_ADDR, ZEDX_ID) \
	zedx_ser##SLOT: zedx_ser_##SLOT@UNIT_ADDR { \
		compatible = "stereolabs,sl_max9295"; \
		reg = <REG_ADDR>; \
		zedx-id = XSTR(ZEDX_ID); \
		channel = "a"; \
		mode = "master"; \
		camera_model = "zedx"; \
		camera-sensors = <&zedx_left##SLOT &zedx_right##SLOT>; \
		imu = <&bmi088_a &bmi088_b>; \
	};

#define ZEDX_ONE_GS_SERIALIZER(SLOT, UNIT_ADDR, REG_ADDR, ZEDX_ID) \
	zedxone_gs_ser##SLOT: zedxone_gs_ser_##SLOT@UNIT_ADDR { \
		compatible = "stereolabs,sl_max9295"; \
		reg = <REG_ADDR>; \
		zedx-id = XSTR(ZEDX_ID); \
		channel = "a"; \
		mode = "master"; \
		camera_model = "zedonegs"; \
		camera-sensors = <&zedxone_gs##SLOT>; \
		imu = <&bmi088_a &bmi088_b>; \
	};

#define ZEDX_ONE_GS_VI_PORT(ID, UNIT_ADDR, REG_ID, VC_ID, VI_PORT_INDEX) \
	port@UNIT_ADDR { \
		reg = <REG_ID>; \
		zedxone_gs_vi_in##ID: endpoint { \
			vc-id = <VC_ID>; \
			port-index = <VI_PORT_INDEX>; \
			bus-width = <NUM_LANES>; \
			remote-endpoint = <&zedxone_gs_csi_out##ID>; \
		}; \
	};

#define ZEDX_ONE_GS_VI_PORT_A(ID, REG_ID, VC_ID, VI_PORT_INDEX) \
	port@REG_ID { \
		reg = <REG_ID>; \
		zedxone_gs_vi_in##ID: endpoint { \
			vc-id = <VC_ID>; \
			port-index = <VI_PORT_INDEX>; \
			bus-width = <NUM_LANES_A>; \
			remote-endpoint = <&zedxone_gs_csi_out##ID>; \
		}; \
	};

#define ZEDX_ONE_GS_VI_PORT_B(ID, REG_ID, VC_ID, VI_PORT_INDEX) \
	port@REG_ID { \
		reg = <REG_ID>; \
		zedxone_gs_vi_in##ID: endpoint { \
			vc-id = <VC_ID>; \
			port-index = <VI_PORT_INDEX>; \
			bus-width = <NUM_LANES_B>; \
			remote-endpoint = <&zedxone_gs_csi_out##ID>; \
		}; \
	};

#define ZEDX_ONE_GS_CSI_CHANNEL(ID, REG_ID, CSI_PORT_INDEX) \
	channel@REG_ID { \
		reg = <REG_ID>; \
		ports { \
			#address-cells = <1>; \
			#size-cells = <0>; \
			port@0 { \
				reg = <0>; \
				zedxone_gs_csi_in##ID: endpoint@0 { \
					port-index = <CSI_PORT_INDEX>; \
					bus-width = <NUM_LANES>; \
					remote-endpoint = <&zedxone_gs_out##ID>; \
				}; \
			}; \
			port@1 { \
				reg = <1>; \
				zedxone_gs_csi_out##ID: endpoint@1 { \
					remote-endpoint = <&zedxone_gs_vi_in##ID>; \
				}; \
			}; \
		}; \
	};

#define ZEDX_ONE_GS_CSI_CHANNEL_A(ID, REG_ID, CSI_PORT_INDEX) \
	channel@REG_ID { \
		reg = <REG_ID>; \
		ports { \
			#address-cells = <1>; \
			#size-cells = <0>; \
			port@0 { \
				reg = <0>; \
				zedxone_gs_csi_in##ID: endpoint@0 { \
					port-index = <CSI_PORT_INDEX>; \
					bus-width = <NUM_LANES_A>; \
					remote-endpoint = <&zedxone_gs_out##ID>; \
				}; \
			}; \
			port@1 { \
				reg = <1>; \
				zedxone_gs_csi_out##ID: endpoint@1 { \
					remote-endpoint = <&zedxone_gs_vi_in##ID>; \
				}; \
			}; \
		}; \
	};

#define ZEDX_ONE_GS_CSI_CHANNEL_B(ID, REG_ID, CSI_PORT_INDEX) \
	channel@REG_ID { \
		reg = <REG_ID>; \
		ports { \
			#address-cells = <1>; \
			#size-cells = <0>; \
			port@0 { \
				reg = <0>; \
				zedxone_gs_csi_in##ID: endpoint@0 { \
					port-index = <CSI_PORT_INDEX>; \
					bus-width = <NUM_LANES_B>; \
					remote-endpoint = <&zedxone_gs_out##ID>; \
				}; \
			}; \
			port@1 { \
				reg = <1>; \
				zedxone_gs_csi_out##ID: endpoint@1 { \
					remote-endpoint = <&zedxone_gs_vi_in##ID>; \
				}; \
			}; \
		}; \
	};
/ {

	overlay-name = ZEDX_OVERLAY_NAME;
	jetson-header-name = "Jetson 22pin CSI Connector";
	compatible = JETSON_COMPATIBLE;

	fragment@0 {
		target-path = "/";
		__overlay__ {

			tegra-capture-vi {
				num-channels = <12>;
				ports {
					#address-cells = <1>;
					#size-cells = <0>;

					/* GMSL0 -> MAX96712 PHY1 -> Orin CSI3. */
					ZEDX_VI_PORT(0, 0, 0, 3)
					ZEDX_VI_PORT(1, 1, 1, 3)
					/* GMSL1 -> MAX96712 PHY0 -> Orin CSI2. */
					ZEDX_VI_PORT(2, 2, 0, 2)
					ZEDX_VI_PORT(3, 3, 1, 2)
					/* GMSL2 -> MAX96712 PHY2 -> Orin CSI0. */
					ZEDX_VI_PORT(4, 4, 0, 0)
					ZEDX_VI_PORT(5, 5, 1, 0)
					/* GMSL3 -> MAX96712 PHY3 -> Orin CSI1. */
					ZEDX_VI_PORT(6, 6, 0, 1)
					ZEDX_VI_PORT(7, 7, 1, 1)

					ZEDX_ONE_GS_VI_PORT(0, 8, 8, 0, 3)
					ZEDX_ONE_GS_VI_PORT(1, 9, 9, 0, 2)
					ZEDX_ONE_GS_VI_PORT(2, a, 10, 0, 0)
					ZEDX_ONE_GS_VI_PORT(3, b, 11, 0, 1)
				};
			};

			tegra-camera-platform {
				compatible = "nvidia, tegra-camera-platform";
				num_csi_lanes = <8>;
				max_lane_speed = <2000000>;
				min_bits_per_pixel = <10>;
				vi_peak_byte_per_pixel = <2>;
				vi_bw_margin_pct = <25>;
				isp_peak_byte_per_pixel = <5>;
				isp_bw_margin_pct = <25>;
				modules {
					ZEDX_CAMERA_MODULE(0, "zedx_left0_ar0234", "frontleft", ZEDX_DEVNAME_LEFT0, ZEDX_PROC_LEFT0)
					ZEDX_CAMERA_MODULE(1, "zedx_right0_ar0234", "frontright", ZEDX_DEVNAME_RIGHT0, ZEDX_PROC_RIGHT0)
					ZEDX_CAMERA_MODULE(2, "zedxone_gs0_ar0234", "front", ZEDX_DEVNAME_ONE_GS0, ZEDX_PROC_ONE_GS0)
					ZEDX_CAMERA_MODULE(3, "zedx_left1_ar0234", "frontleft", ZEDX_DEVNAME_LEFT1, ZEDX_PROC_LEFT1)
					ZEDX_CAMERA_MODULE(4, "zedx_right1_ar0234", "frontright", ZEDX_DEVNAME_RIGHT1, ZEDX_PROC_RIGHT1)
					ZEDX_CAMERA_MODULE(5, "zedxone_gs1_ar0234", "front", ZEDX_DEVNAME_ONE_GS1, ZEDX_PROC_ONE_GS1)
					ZEDX_CAMERA_MODULE(6, "zedx_left2_ar0234", "rearleft", ZEDX_DEVNAME_LEFT2, ZEDX_PROC_LEFT2)
					ZEDX_CAMERA_MODULE(7, "zedx_right2_ar0234", "rearright", ZEDX_DEVNAME_RIGHT2, ZEDX_PROC_RIGHT2)
					ZEDX_CAMERA_MODULE(8, "zedxone_gs2_ar0234", "rear", ZEDX_DEVNAME_ONE_GS2, ZEDX_PROC_ONE_GS2)
					ZEDX_CAMERA_MODULE(9, "zedx_left3_ar0234", "rearleft", ZEDX_DEVNAME_LEFT3, ZEDX_PROC_LEFT3)
					ZEDX_CAMERA_MODULE(10, "zedx_right3_ar0234", "rearright", ZEDX_DEVNAME_RIGHT3, ZEDX_PROC_RIGHT3)
					ZEDX_CAMERA_MODULE(11, "zedxone_gs3_ar0234", "rear", ZEDX_DEVNAME_ONE_GS3, ZEDX_PROC_ONE_GS3)
				};
			};

			bus@0 {
				host1x@13e00000 {
					nvcsi@15a00000 {
						status = "okay";
						num-channels = <12>;
						#address-cells = <1>;
						#size-cells = <0>;

						ZEDX_CSI_CHANNEL(0, 0, 3)
						ZEDX_CSI_CHANNEL(1, 1, 3)
						ZEDX_CSI_CHANNEL(2, 2, 2)
						ZEDX_CSI_CHANNEL(3, 3, 2)
						ZEDX_CSI_CHANNEL(4, 4, 0)
						ZEDX_CSI_CHANNEL(5, 5, 0)
						ZEDX_CSI_CHANNEL(6, 6, 1)
						ZEDX_CSI_CHANNEL(7, 7, 1)

						ZEDX_ONE_GS_CSI_CHANNEL(0, 8, 3)
						ZEDX_ONE_GS_CSI_CHANNEL(1, 9, 2)
						ZEDX_ONE_GS_CSI_CHANNEL(2, 10, 0)
						ZEDX_ONE_GS_CSI_CHANNEL(3, 11, 1)
					};
				};

				TEGRA_ZEDX_GMSL_I2C {
					status = "okay";
					#address-cells = <1>;
					#size-cells = <0>;

					max96712_a@29 {
						compatible = "stereolabs,sl_max96712";
						reg = <0x29>;
						channel = "a";
						reset-gpio = ZEDX_DSER_RESET_GPIO;
						pwdn-gpio = ZEDX_DSER_PWDN_GPIO;
						status = "okay";

						/* Two candidates per physical link. The MAX96712 driver detects
						 * the camera model and activates only the matching slot, so ZED X
						 * and ZED X One GS do not have fixed connector assignments. */
						camera-serializers = <
							/* GMSL 0: ZED X (id=0) OR ZED X One GS (id=4) */
							&zedx_ser0 &zedxone_gs_ser0
							/* GMSL 1: ZED X (id=1) OR ZED X One GS (id=5) */
							&zedx_ser1 &zedxone_gs_ser1
							/* GMSL 2: ZED X (id=2) OR ZED X One GS (id=6) */
							&zedx_ser2 &zedxone_gs_ser2
							/* GMSL 3: ZED X (id=3) OR ZED X One GS (id=7) */
							&zedx_ser3 &zedxone_gs_ser3
						>;
					};

					bmi088_a: bmi088_a@3b {
						compatible = "bmi,bmi088";
						reg = <0x3b>;
						accel_i2c_addr = <0x3c>;
						accel_matrix = [01 00 00 00 01 00 00 00 01];
						gyro_matrix = [01 00 00 00 01 00 00 00 01];
					};

					bmi088_b: bmi088_b@4b {
						compatible = "bmi,bmi088";
						reg = <0x4b>;
						accel_i2c_addr = <0x4c>;
						accel_matrix = [01 00 00 00 01 00 00 00 01];
						gyro_matrix = [01 00 00 00 01 00 00 00 01];
					};

					/* ---- per-link candidate sensors ----
					 *
					 * Output routing extends the existing J401 4x2-lane wiring:
					 *   GMSL0 -> PHY1/CSI3, GMSL1 -> PHY0/CSI2,
					 *   GMSL2 -> PHY2/CSI0, GMSL3 -> PHY3/CSI1.
					 * Only the sensor nodes selected by runtime model detection are
					 * activated, so ZED X and ZED X One GS can use any GMSL input.
					 * GMSL3 previously showed bit errors on one test unit, so that
					 * physical link still requires board-level validation.
					 */

					/* GMSL0: serial_d / Orin CSI3 / MAX96712 opt-csi-port d */
					ZEDX_STEREO_SENSOR(0, left, 28, 0x28, "video0", "ZED_CAM0", 1, 0, 0, "serial_d", "0", 3, "d", 0)
					ZEDX_STEREO_SENSOR(0, right, 20, 0x20, "video1", "ZED_CAM0", 2, 0, 1, "serial_d", "0", 3, "d", 1)
					ZEDX_ONE_GS_SENSOR(0, 10, 0x10, "video8", "ZEDXONE_CAM0", 4, 0, "serial_d", "0", 3, "d")

					/* GMSL1: serial_c / Orin CSI2 / MAX96712 opt-csi-port c */
					ZEDX_STEREO_SENSOR(1, left, 38, 0x38, "video2", "ZED_CAM1", 1, 1, 0, "serial_c", "0", 2, "c", 2)
					ZEDX_STEREO_SENSOR(1, right, 30, 0x30, "video3", "ZED_CAM1", 2, 1, 1, "serial_c", "0", 2, "c", 3)
					ZEDX_ONE_GS_SENSOR(1, 11, 0x11, "video9", "ZEDXONE_CAM1", 5, 0, "serial_c", "0", 2, "c")

					/* GMSL2: serial_a / Orin CSI0 / MAX96712 opt-csi-port e */
					ZEDX_STEREO_SENSOR(2, left, 48, 0x48, "video4", "ZED_CAM2", 1, 2, 0, "serial_a", "6", 0, "e", 4)
					ZEDX_STEREO_SENSOR(2, right, 40, 0x40, "video5", "ZED_CAM2", 2, 2, 1, "serial_a", "6", 0, "e", 5)
					ZEDX_ONE_GS_SENSOR(2, 12, 0x12, "video10", "ZEDXONE_CAM2", 6, 0, "serial_a", "6", 0, "e")

					/* GMSL3: serial_b / Orin CSI1 / MAX96712 opt-csi-port f */
					ZEDX_STEREO_SENSOR(3, left, 14, 0x14, "video6", "ZED_CAM3", 1, 3, 0, "serial_b", "6", 1, "f", 6)
					ZEDX_STEREO_SENSOR(3, right, 41, 0x41, "video7", "ZED_CAM3", 2, 3, 1, "serial_b", "6", 1, "f", 7)
					ZEDX_ONE_GS_SENSOR(3, 13, 0x13, "video11", "ZEDXONE_CAM3", 7, 0, "serial_b", "6", 1, "f")

					/* ---- serializer candidates: two models for every GMSL link ---- */
					ZEDX_SERIALIZER(0, 62, 0x62, 0)
					ZEDX_ONE_GS_SERIALIZER(0, 66, 0x66, 4)
					ZEDX_SERIALIZER(1, 63, 0x63, 1)
					ZEDX_ONE_GS_SERIALIZER(1, 67, 0x67, 5)
					ZEDX_SERIALIZER(2, 64, 0x64, 2)
					ZEDX_ONE_GS_SERIALIZER(2, 68, 0x68, 6)
					ZEDX_SERIALIZER(3, 65, 0x65, 3)
					ZEDX_ONE_GS_SERIALIZER(3, 69, 0x69, 7)
				};
			};
		};
	};

	/* Enable GMSL camera power-over-coax. On the GMSL board the MAX20087 (U4)
	 * enable is CAM_VDD_EN_3V3, which the J401 drives from its PCA9535 expander
	 * (gpio_xten@21 on i2c@c250000) port-0 line 6. The base robo DT leaves this
	 * un-driven (its hog is commented out), so without this the cameras get no
	 * PoC and sl_max96712 reports "Active GMSL ports : 0". Hog it high here so
	 * power comes up with the expander, before the deserializer scans. */
	fragment@1 {
		target = <&gpio_xten>;
		__overlay__ {
			cam-vdd-en-hog {
				gpio-hog;
				output-high;
				gpios = <6 GPIO_ACTIVE_HIGH>;
				line-name = "CAM_VDD_EN_3V3";
			};
		};
	};
};
