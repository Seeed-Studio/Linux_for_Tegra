// SPDX-License-Identifier: GPL-2.0-only
// Stereolabs ZED X / ZED X One GS GMSL overlay.

/dts-v1/;
/plugin/;

#include <dt-bindings/gpio/tegra234-gpio.h>
#include <dt-bindings/clock/tegra234-clock.h>
#include <dt-bindings/tegra234-p3767-0000-common.h>
/* BOARD_CONFIG_MARKER - Do not modify, auto-generated by Makefile */
#include "tegra234-j401-stereolabs-zedx-config.dtsi"

#define NUM_LANES	2
#define NUM_LANES_A	4
#define NUM_LANES_B	4

#define STR(x) #x
#define XSTR(x) STR(x)

#define ZED_ORIN_CLKS \
	clocks = <&bpmp TEGRA234_CLK_EXTPERIPH1>, \
		<&bpmp TEGRA234_CLK_EXTPERIPH1>; \
	clock-names = "extperiph1", "pllp_grtba"; \
	mclk = "extperiph1";

#define AR0234_MODES_LANES_CLK(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY, LANES, SERDES_PIX_CLK) \
	physical_w = "15.0"; \
	physical_h = "12.5"; \
	post_crop_frame_drop = "0"; \
	use_sensor_mode_id = "true"; \
	mode0 { \
		mclk_khz = "24000"; \
		num_lanes = XSTR(LANES); \
		tegra_sinterface = OPT_CSI_SERIAL; \
		lane_polarity = LANE_POLARITY; \
		vc_id = VC_ID; \
		discontinuous_clk = "no"; \
		dpcm_enable = "false"; \
		cil_settletime = "0"; \
		dynamic_pixel_bit_depth = "10"; \
		csi_pixel_bit_depth = "10"; \
		mode_type = "bayer"; \
		pixel_phase = "grbg"; \
		active_w = "1920"; \
		active_h = "1200"; \
		readout_orientation = "0"; \
		line_length = "12496"; \
		inherent_gain = "1"; \
		mclk_multiplier = "3.01"; \
		pix_clk_hz = "229500000"; \
		serdes_pix_clk_hz = SERDES_PIX_CLK; \
		gain_factor = "100"; \
		min_gain_val = "100"; \
		max_gain_val = "1600"; \
		step_gain_val = "1"; \
		default_gain = "100"; \
		min_hdr_ratio = "1"; \
		max_hdr_ratio = "1"; \
		framerate_factor = "1000000"; \
		min_framerate = "15000000"; \
		max_framerate = "60000000"; \
		step_framerate = "15000000"; \
		default_framerate = "30000000"; \
		exposure_factor = "1000000"; \
		min_exp_time = "28"; \
		max_exp_time = "66000"; \
		step_exp_time = "1"; \
		default_exp_time = "13000"; \
		embedded_metadata_height = "0"; \
	}; \
	mode1 { \
		mclk_khz = "24000"; \
		num_lanes = XSTR(LANES); \
		tegra_sinterface = OPT_CSI_SERIAL; \
		lane_polarity = LANE_POLARITY; \
		vc_id = VC_ID; \
		discontinuous_clk = "no"; \
		dpcm_enable = "false"; \
		cil_settletime = "0"; \
		dynamic_pixel_bit_depth = "10"; \
		csi_pixel_bit_depth = "10"; \
		mode_type = "bayer"; \
		pixel_phase = "grbg"; \
		active_w = "960"; \
		active_h = "600"; \
		readout_orientation = "0"; \
		line_length = "6248"; \
		inherent_gain = "1"; \
		mclk_multiplier = "3.01"; \
		pix_clk_hz = "229500000"; \
		serdes_pix_clk_hz = SERDES_PIX_CLK; \
		gain_factor = "100"; \
		min_gain_val = "100"; \
		max_gain_val = "1600"; \
		step_gain_val = "1"; \
		default_gain = "100"; \
		min_hdr_ratio = "1"; \
		max_hdr_ratio = "1"; \
		framerate_factor = "1000000"; \
		min_framerate = "15000000"; \
		max_framerate = "120000000"; \
		step_framerate = "15000000"; \
		default_framerate = "120000000"; \
		exposure_factor = "1000000"; \
		min_exp_time = "28"; \
		max_exp_time = "66000"; \
		step_exp_time = "1"; \
		default_exp_time = "8000"; \
		embedded_metadata_height = "0"; \
	}; \
	mode2 { \
		mclk_khz = "24000"; \
		num_lanes = XSTR(LANES); \
		tegra_sinterface = OPT_CSI_SERIAL; \
		lane_polarity = LANE_POLARITY; \
		vc_id = VC_ID; \
		discontinuous_clk = "no"; \
		dpcm_enable = "false"; \
		cil_settletime = "0"; \
		dynamic_pixel_bit_depth = "10"; \
		csi_pixel_bit_depth = "10"; \
		mode_type = "bayer"; \
		pixel_phase = "grbg"; \
		active_w = "1920"; \
		active_h = "1080"; \
		readout_orientation = "0"; \
		line_length = "12496"; \
		inherent_gain = "1"; \
		mclk_multiplier = "3.01"; \
		pix_clk_hz = "229500000"; \
		serdes_pix_clk_hz = SERDES_PIX_CLK; \
		gain_factor = "100"; \
		min_gain_val = "100"; \
		max_gain_val = "1600"; \
		step_gain_val = "1"; \
		default_gain = "100"; \
		min_hdr_ratio = "1"; \
		max_hdr_ratio = "1"; \
		framerate_factor = "1000000"; \
		min_framerate = "15000000"; \
		max_framerate = "60000000"; \
		step_framerate = "15000000"; \
		default_framerate = "30000000"; \
		exposure_factor = "1000000"; \
		min_exp_time = "28"; \
		max_exp_time = "66000"; \
		step_exp_time = "1"; \
		default_exp_time = "13000"; \
		embedded_metadata_height = "0"; \
	}; \
	mode3 { \
		mclk_khz = "24000"; \
		num_lanes = XSTR(LANES); \
		tegra_sinterface = OPT_CSI_SERIAL; \
		lane_polarity = LANE_POLARITY; \
		vc_id = VC_ID; \
		discontinuous_clk = "no"; \
		dpcm_enable = "false"; \
		cil_settletime = "0"; \
		dynamic_pixel_bit_depth = "10"; \
		csi_pixel_bit_depth = "10"; \
		mode_type = "bayer"; \
		pixel_phase = "grbg"; \
		active_w = "1920"; \
		active_h = "1200"; \
		readout_orientation = "0"; \
		line_length = "12496"; \
		inherent_gain = "1"; \
		mclk_multiplier = "3.01"; \
		pix_clk_hz = "229500000"; \
		serdes_pix_clk_hz = SERDES_PIX_CLK; \
		gain_factor = "100"; \
		min_gain_val = "100"; \
		max_gain_val = "1600"; \
		step_gain_val = "1"; \
		default_gain = "100"; \
		min_hdr_ratio = "1"; \
		max_hdr_ratio = "1"; \
		framerate_factor = "1000000"; \
		min_framerate = "15000000"; \
		max_framerate = "30000000"; \
		step_framerate = "15000000"; \
		default_framerate = "30000000"; \
		exposure_factor = "1000000"; \
		min_exp_time = "28"; \
		max_exp_time = "66000"; \
		step_exp_time = "1"; \
		default_exp_time = "13000"; \
		embedded_metadata_height = "0"; \
	};

#define AR0234_MODES(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY) \
	AR0234_MODES_LANES_CLK(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY, NUM_LANES, "299000000")

#define AR0234_MODES_A(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY) \
	AR0234_MODES_LANES_CLK(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY, NUM_LANES_A, "598000000")

#define AR0234_MODES_B(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY) \
	AR0234_MODES_LANES_CLK(VC_ID, OPT_CSI_SERIAL, LANE_POLARITY, NUM_LANES_B, "598000000")

#define ZEDX_CAMERA_MODULE(ID, BADGE, POSITION, DEVNAME, PROC_DEV_TREE) \
	module##ID { \
		badge = BADGE; \
		position = POSITION; \
		orientation = "1"; \
		drivernode0 { \
			pcl_id = "v4l2_sensor"; \
			devname = DEVNAME; \
			proc-device-tree = PROC_DEV_TREE; \
		}; \
	};

#define ZEDX_ONE_GS_VI_PORT(ID, REG_ID, VC_ID, VI_PORT_INDEX) \
	port@REG_ID { \
		reg = <REG_ID>; \
		zedxone_gs_vi_in##ID: endpoint { \
			vc-id = <VC_ID>; \
			port-index = <VI_PORT_INDEX>; \
			bus-width = <NUM_LANES>; \
			remote-endpoint = <&zedxone_gs_csi_out##ID>; \
		}; \
	};

#define ZEDX_ONE_GS_VI_PORT_A(ID, REG_ID, VC_ID, VI_PORT_INDEX) \
	port@REG_ID { \
		reg = <REG_ID>; \
		zedxone_gs_vi_in##ID: endpoint { \
			vc-id = <VC_ID>; \
			port-index = <VI_PORT_INDEX>; \
			bus-width = <NUM_LANES_A>; \
			remote-endpoint = <&zedxone_gs_csi_out##ID>; \
		}; \
	};

#define ZEDX_ONE_GS_VI_PORT_B(ID, REG_ID, VC_ID, VI_PORT_INDEX) \
	port@REG_ID { \
		reg = <REG_ID>; \
		zedxone_gs_vi_in##ID: endpoint { \
			vc-id = <VC_ID>; \
			port-index = <VI_PORT_INDEX>; \
			bus-width = <NUM_LANES_B>; \
			remote-endpoint = <&zedxone_gs_csi_out##ID>; \
		}; \
	};

#define ZEDX_ONE_GS_CSI_CHANNEL(ID, REG_ID, CSI_PORT_INDEX) \
	channel@REG_ID { \
		reg = <REG_ID>; \
		ports { \
			#address-cells = <1>; \
			#size-cells = <0>; \
			port@0 { \
				reg = <0>; \
				zedxone_gs_csi_in##ID: endpoint@0 { \
					port-index = <CSI_PORT_INDEX>; \
					bus-width = <NUM_LANES>; \
					remote-endpoint = <&zedxone_gs_out##ID>; \
				}; \
			}; \
			port@1 { \
				reg = <1>; \
				zedxone_gs_csi_out##ID: endpoint@1 { \
					remote-endpoint = <&zedxone_gs_vi_in##ID>; \
				}; \
			}; \
		}; \
	};

#define ZEDX_ONE_GS_CSI_CHANNEL_A(ID, REG_ID, CSI_PORT_INDEX) \
	channel@REG_ID { \
		reg = <REG_ID>; \
		ports { \
			#address-cells = <1>; \
			#size-cells = <0>; \
			port@0 { \
				reg = <0>; \
				zedxone_gs_csi_in##ID: endpoint@0 { \
					port-index = <CSI_PORT_INDEX>; \
					bus-width = <NUM_LANES_A>; \
					remote-endpoint = <&zedxone_gs_out##ID>; \
				}; \
			}; \
			port@1 { \
				reg = <1>; \
				zedxone_gs_csi_out##ID: endpoint@1 { \
					remote-endpoint = <&zedxone_gs_vi_in##ID>; \
				}; \
			}; \
		}; \
	};

#define ZEDX_ONE_GS_CSI_CHANNEL_B(ID, REG_ID, CSI_PORT_INDEX) \
	channel@REG_ID { \
		reg = <REG_ID>; \
		ports { \
			#address-cells = <1>; \
			#size-cells = <0>; \
			port@0 { \
				reg = <0>; \
				zedxone_gs_csi_in##ID: endpoint@0 { \
					port-index = <CSI_PORT_INDEX>; \
					bus-width = <NUM_LANES_B>; \
					remote-endpoint = <&zedxone_gs_out##ID>; \
				}; \
			}; \
			port@1 { \
				reg = <1>; \
				zedxone_gs_csi_out##ID: endpoint@1 { \
					remote-endpoint = <&zedxone_gs_vi_in##ID>; \
				}; \
			}; \
		}; \
	};
/ {

	overlay-name = ZEDX_OVERLAY_NAME;
	jetson-header-name = "Jetson 24pin CSI Connector";
	compatible = JETSON_COMPATIBLE;

	fragment@0 {
		target-path = "/";
		__overlay__ {

			tegra-capture-vi {
				num-channels = <4>;
				ports {
					#address-cells = <1>;
					#size-cells = <0>;

					/* ZED X stereo left (VC0) on Orin CSI2 */
					port@0 {
						reg = <0>;
						zedx_vi_in0: endpoint {
							vc-id = <0>;
							port-index = <2>;
							bus-width = <NUM_LANES>;
							remote-endpoint = <&zedx_csi_out0>;
						};
					};

					/* ZED X stereo right (VC1) on Orin CSI2 */
					port@1 {
						reg = <1>;
						zedx_vi_in1: endpoint {
							vc-id = <1>;
							port-index = <2>;
							bus-width = <NUM_LANES>;
							remote-endpoint = <&zedx_csi_out1>;
						};
					};

					/* ZED X One GS #0 (VC0) on Orin CSI3 (link0, known-good) */
					ZEDX_ONE_GS_VI_PORT(0, 2, 0, 3)
					/* ZED X One GS #1 (VC0) on Orin CSI0 (MOVED to link2 -> phy1/PortC/CSI0) */
					ZEDX_ONE_GS_VI_PORT(1, 3, 0, 0)
				};
			};

			tegra-camera-platform {
				compatible = "nvidia, tegra-camera-platform";
				num_csi_lanes = <8>;
				max_lane_speed = <2000000>;
				min_bits_per_pixel = <10>;
				vi_peak_byte_per_pixel = <2>;
				vi_bw_margin_pct = <25>;
				isp_peak_byte_per_pixel = <5>;
				isp_bw_margin_pct = <25>;
				modules {
					ZEDX_CAMERA_MODULE(0, "zedx_ar0234", "bottomleft", ZEDX_DEVNAME_LEFT0, ZEDX_PROC_LEFT0)
					ZEDX_CAMERA_MODULE(1, "zedx_ar0234", "bottomright", ZEDX_DEVNAME_RIGHT0, ZEDX_PROC_RIGHT0)
					ZEDX_CAMERA_MODULE(2, "zedx_ar0234", "topleft", ZEDX_DEVNAME_ONE_GS0, ZEDX_PROC_ONE_GS0)
					ZEDX_CAMERA_MODULE(3, "zedx_ar0234", "topright", ZEDX_DEVNAME_ONE_GS1, ZEDX_PROC_ONE_GS1)
				};
			};

			bus@0 {
				host1x@13e00000 {
					nvcsi@15a00000 {
						status = "okay";
						num-channels = <4>;
						#address-cells = <1>;
						#size-cells = <0>;

						/* ZED X stereo left: Orin CSI2, VC0 */
						channel@0 {
							reg = <0>;
							ports {
								#address-cells = <1>;
								#size-cells = <0>;
								port@0 {
									reg = <0>;
									zedx_csi_in0: endpoint@0 {
										port-index = <2>;
										bus-width = <NUM_LANES>;
										remote-endpoint = <&zedx_ar0234_out0>;
									};
								};
								port@1 {
									reg = <1>;
									zedx_csi_out0: endpoint@16 {
										remote-endpoint = <&zedx_vi_in0>;
									};
								};
							};
						};

						/* ZED X stereo right: Orin CSI2, VC1 */
						channel@1 {
							reg = <1>;
							ports {
								#address-cells = <1>;
								#size-cells = <0>;
								port@0 {
									reg = <0>;
									zedx_csi_in1: endpoint@1 {
										port-index = <2>;
										bus-width = <NUM_LANES>;
										remote-endpoint = <&zedx_ar0234_out1>;
									};
								};
								port@1 {
									reg = <1>;
									zedx_csi_out1: endpoint@17 {
										remote-endpoint = <&zedx_vi_in1>;
									};
								};
							};
						};

						/* ZED X One GS #0: Orin CSI3, VC0 (link0, known-good) */
						ZEDX_ONE_GS_CSI_CHANNEL(0, 2, 3)
						/* ZED X One GS #1: Orin CSI0, VC0 (MOVED to link2 -> phy1/PortC/CSI0) */
						ZEDX_ONE_GS_CSI_CHANNEL(1, 3, 0)
					};
				};

				TEGRA_ZEDX_GMSL_I2C {
					status = "okay";
					#address-cells = <1>;
					#size-cells = <0>;

					max96712_a@29 {
						compatible = "stereolabs,sl_max96712";
						reg = <0x29>;
						channel = "a";
						reset-gpio = ZEDX_DSER_RESET_GPIO;
						pwdn-gpio = ZEDX_DSER_PWDN_GPIO;
						status = "okay";

						/* Per-GMSL-port candidate matrix.
						 *
						 * With >2 cameras the sl_max96712 driver matches the Nth
						 * serializer *of a given model* in this list to physical
						 * GMSL link #N ("1st ZED X entry -> GMSL #0, 3rd -> GMSL #2").
						 * So every link lists one slot per supported model, in link
						 * order, and slots with no camera of that model plugged are
						 * filled with zedx-id="-1" dummies (the driver's documented
						 * "set a dummy instead" mechanism). Links are padded to all
						 * four so n_serializers stays a multiple of 4.
						 *
						 * Physical wiring (link2 fix): GMSL0=GS, GMSL1=ZED X, GMSL2=GS,
						 * GMSL3 EMPTY. The 2nd GS was moved off the faulty GMSL link3 input
						 * onto the spare link2. Keep the cameras plugged exactly this way. */
						camera-serializers = <
							/* GMSL 0 */ &dummy_zedx_ser0	&zedxone_gs_ser0
							/* GMSL 1 */ &zedx_ser0		&dummy_gs_ser1
							/* GMSL 2 */ &dummy_zedx_ser2	&zedxone_gs_ser1
							/* GMSL 3 */ &dummy_zedx_ser3	&dummy_gs_ser3
						>;
					};

					bmi088_a: bmi088_a@3b {
						compatible = "bmi,bmi088";
						reg = <0x3b>;
						accel_i2c_addr = <0x3c>;
						accel_matrix = [01 00 00 00 01 00 00 00 01];
						gyro_matrix = [01 00 00 00 01 00 00 00 01];
					};

					bmi088_b: bmi088_b@4b {
						compatible = "bmi,bmi088";
						reg = <0x4b>;
						accel_i2c_addr = <0x4c>;
						accel_matrix = [01 00 00 00 01 00 00 00 01];
						gyro_matrix = [01 00 00 00 01 00 00 00 01];
					};

					/* ---- serializers ---- */

					/* ZED X stereo on GMSL link #1 -> zedx-id 1 (base 0 + link 1) */
					zedx_ser0: zedx_ser_0@62 {
						compatible = "stereolabs,sl_max9295";
						reg = <0x62>;
						zedx-id = "1";
						channel = "a";
						mode = "master";
						camera_model = "zedx";
						camera-sensors = <&zedx_left0 &zedx_right0>;
						imu = <&bmi088_a &bmi088_b>;
					};

					/* ZED X One GS, zedx-id 4 */
					zedxone_gs_ser0: zedxone_gs_ser_0@66 {
						compatible = "stereolabs,sl_max9295";
						reg = <0x66>;
						zedx-id = "4";
						channel = "a";
						mode = "master";
						camera_model = "zedonegs";
						camera-sensors = <&zedxone_gs0>;
						imu = <&bmi088_a &bmi088_b>;
					};

					/* ZED X One GS on GMSL link #2 -> zedx-id 6 (base 4 + link 2).
					 * MOVED off faulty link3 (was id7); must match zedxone_gs1's zedx-id. */
					zedxone_gs_ser1: zedxone_gs_ser_1@67 {
						compatible = "stereolabs,sl_max9295";
						reg = <0x67>;
						zedx-id = "6";
						channel = "a";
						mode = "master";
						camera_model = "zedonegs";
						camera-sensors = <&zedxone_gs1>;
						imu = <&bmi088_a &bmi088_b>;
					};

					/* ---- dummy serializers (placement placeholders) ----
					 * Fill per-model GMSL slots that have no camera of that model
					 * plugged, so the driver's >2-camera link#->model-index matching
					 * lines up. zedx-id "-1" => parsed into sensor_list but never
					 * probed or activated. No compatible/reg => not an i2c device.
					 * A stereo (zedx) dummy needs TWO camera-sensors entries so the
					 * placement loop's stereo skip consumes the right list slots; the
					 * referenced dummy_cam node is never dereferenced for id -1. */
					dummy_cam: dummy_cam {};

					dummy_zedx_ser0: dummy_zedx_ser_0 {
						camera_model = "zedx";
						zedx-id = "-1";
						camera-sensors = <&dummy_cam &dummy_cam>;
					};

					dummy_zedx_ser2: dummy_zedx_ser_2 {
						camera_model = "zedx";
						zedx-id = "-1";
						camera-sensors = <&dummy_cam &dummy_cam>;
					};

					dummy_zedx_ser3: dummy_zedx_ser_3 {
						camera_model = "zedx";
						zedx-id = "-1";
						camera-sensors = <&dummy_cam &dummy_cam>;
					};

					dummy_gs_ser1: dummy_gs_ser_1 {
						camera_model = "zedonegs";
						zedx-id = "-1";
						camera-sensors = <&dummy_cam>;
					};

					dummy_gs_ser2: dummy_gs_ser_2 {
						camera_model = "zedonegs";
						zedx-id = "-1";
						camera-sensors = <&dummy_cam>;
					};

					dummy_gs_ser3: dummy_gs_ser_3 {
						camera_model = "zedonegs";
						zedx-id = "-1";
						camera-sensors = <&dummy_cam>;
					};

					/* ---- sensor nodes (all channel = "a") ---- */

					/* ZED X stereo left: GMSL #1 -> dphy out0 -> Orin CSI2, VC0 */
					zedx_left0: zedx_left_0@28 {
						compatible = "stereolabs,zedx";
						reg = <0x28>;

						ZED_ORIN_CLKS

						devnode = "video0";
						sync_sensor = "ZED_CAM0";
						sync_sensor_index = <1>;

						zedx-id = "1";
						channel = "a";

						has-eeprom;
						eeprom-addr = <0x54>;

						AR0234_MODES("0", "serial_c", "0")

						ports {
							#address-cells = <1>;
							#size-cells = <0>;
							port@0 {
								reg = <0>;
								zedx_ar0234_out0: endpoint {
									vc-id = <0>;
									port-index = <2>;
									opt-csi-port = "c";
									bus-width = <NUM_LANES>;
									i2c-cc = <0>;
									remote-endpoint = <&zedx_csi_in0>;
								};
							};
						};
					};

					/* ZED X stereo right: GMSL #1 -> dphy out0 -> Orin CSI2, VC1 */
					zedx_right0: zedx_right_0@20 {
						compatible = "stereolabs,zedx";
						reg = <0x20>;

						ZED_ORIN_CLKS

						devnode = "video1";
						sync_sensor = "ZED_CAM0";
						sync_sensor_index = <2>;

						zedx-id = "1";
						channel = "a";

						has-eeprom;
						eeprom-addr = <0x54>;

						AR0234_MODES("1", "serial_c", "0")

						ports {
							#address-cells = <1>;
							#size-cells = <0>;
							port@0 {
								reg = <0>;
								zedx_ar0234_out1: endpoint {
									vc-id = <1>;
									port-index = <2>;
									opt-csi-port = "c";
									bus-width = <NUM_LANES>;
									i2c-cc = <0>;
									remote-endpoint = <&zedx_csi_in1>;
								};
							};
						};
					};

					/* ZED X One GS (id4): GMSL #0 -> dphy out1 -> Orin CSI3, VC0
					 * (known-good; restored from swap-test back to its proven output) */
					zedxone_gs0: zedxone_gs_0@10 {
						compatible = "stereolabs,zedx";
						reg = <0x10>;

						ZED_ORIN_CLKS

						devnode = "video2";
						sync_sensor = "ZEDXONE_CAM0";
						sync_sensor_index = <1>;

						zedx-id = "4";
						channel = "a";

						has-eeprom;
						eeprom-addr = <0x56>;

						AR0234_MODES("0", "serial_d", "0")

						ports {
							#address-cells = <1>;
							#size-cells = <0>;
							port@0 {
								reg = <0>;
								zedxone_gs_out0: endpoint {
									vc-id = <0>;
									port-index = <3>;
									opt-csi-port = "d";
									bus-width = <NUM_LANES>;
									i2c-cc = <0>;
									remote-endpoint = <&zedxone_gs_csi_in0>;
								};
							};
						};
					};

					/* ZED X One GS (id6): GMSL #2 -> dphy out2 -> Orin CSI0, VC0
					 * MOVED off faulty GMSL link3 input (link3 has bit errors: the camera
					 * produces a lockable but corrupt stream there). link2 input is healthy.
					 * 2-lane serial_a/phy2/CSI0 output. */
					zedxone_gs1: zedxone_gs_1@11 {
						compatible = "stereolabs,zedx";
						reg = <0x11>;

						ZED_ORIN_CLKS

						devnode = "video3";
						sync_sensor = "ZEDXONE_CAM1";
						sync_sensor_index = <1>;

						zedx-id = "6";
						channel = "a";

						has-eeprom;
						eeprom-addr = <0x56>;

						AR0234_MODES("0", "serial_a", "6")

						ports {
							#address-cells = <1>;
							#size-cells = <0>;
							port@0 {
								reg = <0>;
								zedxone_gs_out1: endpoint {
									vc-id = <0>;
									port-index = <0>;
									opt-csi-port = "e";
									bus-width = <NUM_LANES>;
									i2c-cc = <0>;
									remote-endpoint = <&zedxone_gs_csi_in1>;
								};
							};
						};
					};
				};
			};
		};
	};

	/* Enable GMSL camera power-over-coax. On the GMSL board the MAX20087 (U4)
	 * enable is CAM_VDD_EN_3V3, which the J401 drives from its PCA9535 expander
	 * (gpio_xten@21 on i2c@c250000) port-0 line 6. The base robo DT leaves this
	 * un-driven (its hog is commented out), so without this the cameras get no
	 * PoC and sl_max96712 reports "Active GMSL ports : 0". Hog it high here so
	 * power comes up with the expander, before the deserializer scans. */
	fragment@1 {
		target = <&gpio_xten>;
		__overlay__ {
			cam-vdd-en-hog {
				gpio-hog;
				output-high;
				gpios = <6 GPIO_ACTIVE_HIGH>;
				line-name = "CAM_VDD_EN_3V3";
			};
		};
	};
};
